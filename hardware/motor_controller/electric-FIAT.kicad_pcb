File: hardware/motor_controller/electric-FIAT.kicad_pcb (KiCad board)
At the start: 2 copper layers, 105.3 x 169.1 mm, 229 parts, among them J1 CAN, J10 Motor_W, J11 SKiiP 613 GD123-3DUL V3, J12 Encoder, J13 Accelerator, J14 12V Battery, J15 5.1k, J2 Expansion, J3 Debug, J4 RTMI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

Commit message: Add FOC_reset and fix compilation errors
Parts:
- added R29: R, Resistor_SMD:R_0805_2012Metric, F.Cu at (29.4, 66.8)
- renumbered R29 to R30, R30 to R31, R31 to R32, R32 to R33, R33 to R34, R34 to R35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
Connections:
- U6 pad 21: /SPI2_NSS -> /FOC_reset
- U7 pad 50: /reset -> /FOC_reset

Commit message: PCB placing done, missing some connections
Parts:
- removed the C16 at (102.6, 114.2)
- removed the C17 at (108.1, 110.7)
- removed the C25 at (98.1, 102.2)
- removed the C26 at (105.2, 105.6)
- removed the C35 at (-14.8, 133.8)
- removed the C36 at (29.2, 90.7)
- removed the C37 at (-32.2, 153.1)
- removed the C38 at (-9.45, 70.4)
- removed the C39 at (102.8, 116.6)
- removed the C40 at (105.3, 121.5)
- removed the C41 at (-6.68, 127.9)
- removed the C42 at (33.4, 87.8)
- removed the C52 at (124.9, 109.3)
- removed the C53 at (122.3, 104.4)
- removed the C65 at (99.0, 142.9)
- removed the C69 at (20.1, 88.9)
- removed D2: Blue, LED_SMD:LED_0805_2012Metric
- removed D3: White, LED_SMD:LED_0805_2012Metric
- removed D4, D5, D6, D8: Red, LED_SMD:LED_0805_2012Metric
- removed D7: Yellow, LED_SMD:LED_0805_2012Metric
- removed the J2 at (111.3, 43.8)
- removed the R22 at (28.4, 81.9)
- removed the R30 at (24.6, 87.8)
- removed the R35 at (-14.8, 136.7)
- removed the R62 at (-11.1, 127.9)
- removed the R65 at (123.0, 107.3)
- removed the R68 at (-28.0, 138.1)
- removed the R75 at (-19.5, 144.0)
- removed the R80 at (-11.1, 130.8)
- removed the R89 at (-2.29, 121.2)
- removed the R90 at (-19.2, 137.6)
- removed R95: 2.7k, Resistor_SMD:R_0805_2012Metric
- removed R96: 2.2k, Resistor_SMD:R_0805_2012Metric
- added C18: 1n, Capacitor_SMD:C_0805_2012Metric, B.Cu at (99.6, 69.5)
- added C19: 100n, Capacitor_SMD:C_0805_2012Metric, B.Cu at (106.0, 65.1)
- added C2: 100n, Capacitor_SMD:C_0603_1608Metric, B.Cu at (92.1, 88.9)
- added C20: 100n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (93.1, 63.9)
- added C21: 100n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (96.6, 69.4)
- added C3: 100n, Capacitor_SMD:C_0603_1608Metric, B.Cu at (89.0, 88.9)
- added C32: 100n, Capacitor_SMD:C_0603_1608Metric, F.Cu at (93.1, 99.7)
- added C33: 10n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (105.1, 59.4)
- added C34: 1n, Capacitor_SMD:C_0805_2012Metric, B.Cu at (101.7, 66.5)
- added C4: 100n, Capacitor_SMD:C_0603_1608Metric, F.Cu at (88.0, 96.2)
- added C43: 100p, Capacitor_SMD:C_0805_2012Metric, B.Cu at (128.7, 80.7)
- added C44: 100n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (118.8, 81.9)
- added C45: 100n, Capacitor_SMD:C_0805_2012Metric, B.Cu at (131.7, 83.6)
- added C46: 100n, Capacitor_SMD:C_0805_2012Metric, B.Cu at (122.3, 81.7)
- added C47: 1n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (87.6, 66.1)
- added C48: 100n, Capacitor_SMD:C_0805_2012Metric, F.Cu at (79.7, 66.1)
- added C49: 100p, Capacitor_SMD:C_0805_2012Metric, B.Cu at (120.8, 88.7)
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Connections:
- net /SPI1_CS_Accel renamed /SPI_CS_Accel
- net /SPI1_CS_Gyro renamed /SPI_CS_Gyro
- net /SPI1_CS_Magnet renamed /SPI_CS_Magnet
- net /SPI2_MISO renamed /SPI_MISO
- net /SPI2_MOSI renamed /SPI_MOSI
- net /SPI2_NSS renamed /SPI_CS_FOC
- net /SPI2_SCK renamed /SPI_SCK
- net Net-(J1-Pad1) renamed /CAN_N
- net Net-(J1-Pad2) renamed /CAN_P
- C14 pad 1: Net-(C14-Pad1) -> +3V3
- C14 pad 2: /DC_Bus_Voltage -> GND
- C15 pad 1: +5V -> +3V3
- C22 pad 1: /VCC_CORE -> /1V8_1
- C23 pad 1: /VCC_CORE -> /1V8_2
- C24 pad 1: /VCC_CORE -> /1V8_3
- C41 pad 2: GND -> GNDPWR
- C57 pad 1: Net-(C49-Pad1) -> Net-(C57-Pad1)
- C59 pad 2: GND -> GNDPWR
- C67 pad 1: +BATT -> Net-(C67-Pad1)
- C67 pad 2: -BATT -> GND
- C70 pad 1: -BATT -> +3V3
- C79 pad 1: Net-(C68-Pad1) -> Net-(C79-Pad1)
- J11 pad 12: (no net) -> Net-(J11-Pad12)
- J11 pad 13: (no net) -> Net-(J11-Pad13)
- J11 pad 21: (no net) -> GND
- J11 pad 22: (no net) -> Net-(J11-Pad22)
- J11 pad 23: (no net) -> GND
- J11 pad 24: (no net) -> Net-(J11-Pad24)
- J11 pad 25: (no net) -> GND
- J11 pad 26: (no net) -> Net-(J11-Pad26)
- J11 pad 3: /ERROR_HB1 -> Net-(J11-Pad3)
- J11 pad 6: /ERROR_HB2 -> Net-(J11-Pad6)
- J11 pad 9: /ERROR_HB3 -> Net-(J11-Pad9)
- J2 pad 11: (no net) -> Net-(J2-Pad11)
- J2 pad 14: (no net) -> Net-(J2-Pad14)
- J2 pad 16: (no net) -> Net-(J2-Pad16)
- J2 pad 17: (no net) -> Net-(J2-Pad17)
- J2 pad 18: (no net) -> Net-(J2-Pad18)
- J2 pad 19: (no net) -> Net-(J2-Pad19)
- J2 pad 2: (no net) -> Net-(J2-Pad2)
- J2 pad 20: (no net) -> Net-(J2-Pad20)
- J2 pad 3: (no net) -> Net-(J2-Pad3)
- J2 pad 5: (no net) -> Net-(J2-Pad5)
- J4 pad 2: (no net) -> Net-(J4-Pad2)
- J6 pad 1: /DC+ -> +VDC
- J6 pad 2: +VDC -> /DC+
- R1 pad 1: Net-(C14-Pad1) -> Net-(C18-Pad1)
- R15 pad 2: GND -> GNDPWR
- R16 pad 2: Net-(C14-Pad1) -> Net-(C18-Pad1)
- R17 pad 1: Net-(C14-Pad1) -> Net-(C18-Pad1)
- R22 pad 2: Net-(R21-Pad2) -> Net-(R22-Pad2)
- R23 pad 1: Net-(R22-Pad1) -> Net-(R23-Pad1)
- R23 pad 2: Net-(R23-Pad2) -> Net-(R22-Pad2)
- R24 pad 1: Net-(R24-Pad1) -> Net-(R23-Pad1)
- R24 pad 2: Net-(R23-Pad2) -> Net-(R24-Pad2)
- R25 pad 1: Net-(R24-Pad1) -> Net-(R25-Pad1)
- R25 pad 2: Net-(R25-Pad2) -> Net-(R24-Pad2)
- R26 pad 1: Net-(R26-Pad1) -> Net-(R25-Pad1)
- R26 pad 2: Net-(R25-Pad2) -> Net-(R26-Pad2)
- R27 pad 1: Net-(R26-Pad1) -> Net-(R27-Pad1)
- R27 pad 2: Net-(R27-Pad2) -> Net-(R26-Pad2)
- R28 pad 1: /Motor_U -> Net-(R27-Pad1)
- R28 pad 2: Net-(R27-Pad2) -> Net-(R28-Pad2)
- R33 pad 2: GND -> GNDPWR
- R36 pad 1: Net-(R36-Pad1) -> Net-(C43-Pad1)
- R36 pad 2: Net-(C41-Pad1) (its old number) -> /Motor_Voltage_V
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Routing:
- net +5V: track 19.9 -> 297.2 mm, vias 1 -> 5
- net GNDPWR: track 0.00 -> 169.7 mm, vias 0 -> 4
- net /Motor_Voltage_U: track 0.00 -> 123.8 mm, vias 0 -> 9
- net GND: track 11.9 -> 127.6 mm, vias 15 -> 34
- net /Motor_Voltage_V: track 0.00 -> 104.9 mm, vias 0 -> 4
- net +3V3: track 16.2 -> 110.3 mm, vias 2 -> 29
- net /SPI_SCK: track 0.00 -> 85.8 mm, vias 0 -> 3
- net /SPI_MOSI: track 0.00 -> 80.6 mm, vias 0 -> 2
- net /SPI_MISO: track 0.00 -> 76.8 mm, vias 0 -> 2
- net /Motor_Voltage_W: track 3.58 -> 64.4 mm, vias 1 -> 3
- net /braking_pedal: track 0.00 -> 56.4 mm, vias 0 -> 1
- net +15V: track 0.00 -> 55.6 mm
- net /SPI_CS_Gyro: track 0.00 -> 46.8 mm, vias 0 -> 1
- net /SPI_CS_Magnet: track 0.00 -> 46.3 mm, vias 0 -> 1
- net /SPI_CS_Accel: track 0.00 -> 44.4 mm, vias 0 -> 1
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Other:
- net class Default: via_dia 0.8 -> 0.6; via_drill 0.4 -> 0.3

Commit message: PCB layout complete
Connections:
- J11 pad 11: /IGBT_OVER_TEMP -> Net-(J11-Pad11)
- U6 pad 2: /IGBT_OVER_TEMP -> Net-(U6-Pad2)
- U7 pad 16: /Motor_Current_U -> /Motor_Current_V
- U7 pad 18: /Motor_Current_V -> /Motor_Current_W
Routing:
- net /Motor_Current_U: track 5.27 -> 136.3 mm, vias 0 -> 5
- net /Motor_Current_W: track 2.01 -> 129.0 mm, vias 0 -> 5
- net /Motor_Current_V: track 5.22 -> 126.3 mm, vias 0 -> 10
- net /DC_Current: track 4.84 -> 79.0 mm, vias 2 -> 7
- net /DC_Bus_Voltage: track 3.14 -> 69.4 mm, vias 1 -> 4
- net +24V: track 2.89 -> 55.7 mm
- net /TEMP_OUT: track 0.00 -> 36.5 mm, vias 0 -> 1
- net +3V3: track 110.3 -> 138.3 mm, vias 29 -> 39
- net GND: track 127.6 -> 151.5 mm, vias 34 -> 39
- net GNDPWR: track 169.7 -> 181.8 mm
- net /MCO_TMC_CLK: track 42.4 -> 46.5 mm
- net +15V: track 55.6 -> 59.2 mm
- net Net-(D1-Pad1): track 0.00 -> 1.99 mm
- net /PWM_VT: track 20.5 -> 21.6 mm, vias 2 -> 3
- net Net-(R87-Pad1): vias 0 -> 1
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Other:
- net class Default: clearance 0.2 -> 0.15
- rule trace_clearance: 0.2 -> 0.15
