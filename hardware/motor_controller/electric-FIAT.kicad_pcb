# Repository G-Pereira/Electric_Car_FOC_Controller

File README.md:

# Electric-FIAT
Motor controlller for a FIAT UNO electric car transformation

## KiCad design hardware/motor_controller/electric-FIAT.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C21, C22, C23, C26, C31: 100n; C_0603_1608Metric
C10, C13, C30: 4.7u; C_0603_1608Metric
C11, C12: 12p; C_0805_2012Metric
C14: 470n; C_0603_1608Metric
C15, C16, C18, C19, C20, C34, C35, C37, C38, C39, C43, C44, C45, C47, C51, C53, C54, C55, C56, C60, C62, C65, C66, C67, C68, C69, C70, C78: 100n; C_0805_2012Metric
C17, C33, C46, C50, C59, C64, C71: 1n; C_0805_2012Metric
C24, C25: 2.2n; C_0603_1608Metric
C27: 1u; C_0603_1608Metric
C28, C29: 30p; C_0805_2012Metric
C32: 10n; C_0805_2012Metric
C36, C40, C41, C42, C48, C49, C52, C58, C61: 100p; C_0805_2012Metric
C57, C63: 50p; C_0805_2012Metric
C72, C73: 100u; CP_Radial_D10.0mm_P5.00mm
C74, C77: 10u; C_0805_2012Metric
C75: 270u; CP_Radial_D10.0mm_P5.00mm
C76: 680p; C_0805_2012Metric
C79, C80, C81: 1n; C_1206_3216Metric
D1: Green; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_5.3mm_M5
J1: CAN; PhoenixContact_MCV_1,5_2-G-3.81_1x02_P3.81mm_Vertical
J2: Debug; IDC-Header_2x10_P2.54mm_Vertical
J3: DC_Bus; PhoenixContact_MCV_1,5_2-G-3.81_1x02_P3.81mm_Vertical
J4: RTMI; IDC-Header_2x05_P2.54mm_Vertical
J5: Micro_SD_Card_Det; microSD_HC_Hirose_DM3D-SF
J6: Batt_conn; Motor_IGBT
J7: Motor_U; Motor_IGBT
J8: IMU; PinSocket_1x10_P2.54mm_Vertical
J9: Motor_V; Motor_IGBT
J10: Motor_W; Motor_IGBT
J11: SKiiP 613 GD123-3DUL V3; IDC-Header_2x13_P2.54mm_Vertical_Lock
J12: Encoder; PhoenixContact_MCV_1,5_4-G-3.81_1x04_P3.81mm_Vertical
J13: Accelerator; PhoenixContact_MCV_1,5_3-G-3.81_1x03_P3.81mm_Vertical
J14: 9-18V Battery; PhoenixContact_MCV_1,5_2-G-5.08_1x02_P5.08mm_Vertical
J15: 5.1k; PhoenixContact_MCV_1,5_3-G-3.81_1x03_P3.81mm_Vertical
L1: 4.7u; L_Coilcraft_LPS4018
Q1, Q2, Q3, Q4, Q5, Q6: AO3400; SOT-23
R1, R14, R16, R17: 20k; R_0805_2012Metric
R2, R3, R4, R5, R6: 33k; R_0805_2012Metric
R7, R8, R9, R10, R11: 27k; R_0805_2012Metric
R12: 120; R_0805_2012Metric
R13: 39; R_0805_2012Metric
R15, R88, R92: 2k; R_0805_2012Metric
R18, R30, R31, R33, R49, R67: 10k; R_0805_2012Metric
R19, R87, R89, R93: 1k; R_0805_2012Metric
R20, R32, R36, R47, R53, R65: 5k1; R_0805_2012Metric
R21, R22, R23, R37, R38, R39, R54, R55, R56: 200k; R_0805_2012Metric
R24, R25, R26, R40, R41, R42, R57, R58, R59: 220k; R_0805_2012Metric
R27, R28, R43, R44, R60, R61: 270k; R_0805_2012Metric
R29, R45, R62: 0; R_0805_2012Metric
R34, R35, R50, R51, R68, R73: 12k; R_0805_2012Metric
R46, R52, R66, R80, R81, R94: 4.7k; R_0805_2012Metric
R48: 10k; R_0603_1608Metric
R63, R74: 1.5k; R_0805_2012Metric
R64, R75, R90: 3.3k; R_0805_2012Metric
R69, R71, R76, R78, R82, R84: 910; R_0805_2012Metric
R70, R72, R77, R79, R83, R85: 1k2; R_0805_2012Metric
R86: 2.2k; R_0805_2012Metric
R91: 2.7k; R_0805_2012Metric
TH1: KTY81; PhoenixContact_MCV_1,5_2-G-5.08_1x02_P5.08mm_Vertical
U1: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U2, U4, U9, U15: ACPL-C87A; SSO-8_6.8x5.9mm_P1.27mm_Clearance8mm
U3, U5, U10, U12, U16, U17, U21, U22, U26, U27: OPA356xxDBV; SOT-23-5
U6: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm
U7: TMC4671-ES; QFN76P; MPN TMC4671-ES
U8, U11, U14, U19: ACS759xCB-200B-PFF; Allegro_CB_PFF
U13, U18, U20: 74LVC1G14; Texas_R-PDSO-G5
U23: ITW1205SA; Converter_DCDC_XP_POWER-ITWxxxxSA_THT
U24: IU1203SA; Converter_DCDC_XP_POWER-IUxxxxSA_THT
U25: TEN40-1215E; Converter_DCDC_TRACO_TEN40-xxxxE
Y1: 32.768MHz; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y2: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C15.1, C18.1, C30.1, C31.1, C34.1, C37.1, C43.1, C53.1, C72.1, J12.1, J13.1, U1.3 (VDD), U2.1 (VDD1), U4.1 (VDD1), U7.23 (V5), U9.1 (VDD1), U15.1 (VDD1), U23.4 (+Vout)
+15V: J11.16, J11.17, R70.1, R72.1, R77.1, R79.1, R83.1, R85.1
+24V: C71.2, J11.14, J11.15, U25.4 (VOUT+)
+BATT: C71.1, C74.1, C75.1, C76.1, C77.1, J14.1, L1.1, U24.2 (+Vin), U25.1 (VIN+)
+VDC: J6.1, R11.1, U8.4 (IP+)
-BATT: C74.2, C75.2, C77.2, C79.1, C80.1, C81.1, J14.2, U23.1 (-Vin), U24.1 (-Vin), U25.2 (VIN-)
/1V8_1: C21.1, U7.63 (VCCCORE3)
/1V8_2: C22.1, U7.15 (VCCCORE1)
/1V8_3: C23.1, U7.45 (VCCCORE2)
/CAN_N: J1.1, R12.2, U1.6 (CANL)
/CAN_P: J1.2, R12.1, U1.7 (CANH)
/CAN_RX: U1.1 (TXD), U6.44 (PA11)
/CAN_STBY: U1.8 (STBY), U6.57 (PB5)
/CAN_TX: U1.4 (RXD), U6.45 (PA12)
/DBGSPI_MISO: J4.9, U7.4 (GPIO6/AENC_VN_MCD/DBGSPI_MISO)
/DBGSPI_MOSI: J4.7, U7.1 (GPIO5/AENC_UX_MCD/DBGSPI_MOSI)
/DBGSPI_SCK: J4.5, U7.76 (GPIO4/AGPI_B_MCD/DBGSPI_SCK)
/DBGSPI_TRG: J4.4, U7.5 (GPIO7/AENC_WY_MCD/DBGSPI_TRG)
/DBGSPI_nSCS: J4.3, U7.75 (GPIO3/AGPI_A_MCD/DBGSPI_nSCS)
/DC+: J6.2, U8.5 (IP-)
/DC_Bus_Voltage: C17.2, R1.2, U3.1, U6.17 (PA3)
/DC_Current: C46.1, R46.1, U6.22 (PA6)
/ENABLE_INPUTS: R48.2, U7.55 (ENI)
/ENC_A: U7.25 (AENC_UX_POS), U12.1, U12.4 (-), U13.2
/ENC_A_R: J12.2, R63.1
/ENC_A_T: C57.1, U6.14 (PA0), U13.4
/ENC_B: U7.29 (AENC_WY_POS), U17.1, U17.4 (-), U18.2
/ENC_B_R: J12.3, R74.1
/ENC_B_T: C63.1, U6.15 (PA1), U18.4
/HB_UB: J11.2, Q2.3 (D), R72.2
/HB_UT: J11.4, Q1.3 (D), R70.2
/HB_VB: J11.5, Q4.3 (D), R79.2
/HB_VT: J11.7, Q3.3 (D), R77.2
/HB_WB: J11.8, Q6.3 (D), R85.2
/HB_WT: J11.10, Q5.3 (D), R83.2
/HSE_IN: C28.1, U6.5 (PH0), Y2.1
/HSE_OUT: C29.1, U6.6 (PH1), Y2.3
/IGBT_Temp: R88.1, U6.27 (PB1), U22.1
/IGBT_U: J7.1, U11.4 (IP+)
/IGBT_V: J9.1, U14.4 (IP+)
/IGBT_W: J10.1, U19.4 (IP+)
/LSE_IN: C11.1, U6.3 (PC14), Y1.1
/LSE_OUT: C12.1, U6.4 (PC15), Y1.2
/MCO_TMC_CLK: U6.41 (PA8), U20.2
/Motor_Current_U: C50.1, R52.1, U6.8 (PC0)
/Motor_Current_V: C59.1, R66.1, U6.9 (PC1), U7.16 (ADC_I0_POS)
/Motor_Current_W: C64.1, R80.1, U6.16 (PA2), U7.18 (ADC_I1_POS)
/Motor_U: J7.2, R29.1, U11.5 (IP-)
/Motor_V: J9.2, R45.1, U14.5 (IP-)
/Motor_Voltage_U: C36.2, R20.2, U5.1, U6.23 (PA7)
/Motor_Voltage_V: C42.2, R36.2, U6.24 (PC4), U10.1
/Motor_Voltage_W: C52.2, R53.2, U6.25 (PC5), U16.1
/Motor_W: J10.2, R62.1, U19.5 (IP-)
/Motor_temp: R94.1, U6.26 (PB0), U27.1
/PWM_UB: Q2.2 (S), R71.2, U7.40 (PWM_UX1_L)
/PWM_UT: Q1.2 (S), R69.2, U7.39 (PWM_UX1_H)
/PWM_VB: Q4.2 (S), R78.2, U7.42 (PWM_VX2_L)
/PWM_VT: Q3.2 (S), R76.2, U7.41 (PWM_VX2_H)
/PWM_WB: Q6.2 (S), R84.2, U7.47 (PWM_WY1_L)
/PWM_WT: Q5.2 (S), R82.2, U7.46 (PWM_WY1_H)
/SD_CLK: J5.5 (CLK), U6.53 (PC12)
/SD_CMD: J5.3 (CMD), U6.54 (PD2)
/SD_DAT0: J5.7 (DAT0), U6.39 (PC8)
/SD_DAT1: J5.8 (DAT1), U6.40 (PC9)
/SD_DAT2: J5.1 (DAT2), U6.51 (PC10)
/SD_DAT3: J5.2 (DAT3/CD), U6.52 (PC11)
/SD_DET: J5.9 (DET_B), R31.1, U6.38 (PC7)
/SPI_CS_Accel: J8.8, U6.20 (PA4)
/SPI_CS_FOC: U6.33 (PB12), U7.6 (SPI_nSCS)
/SPI_CS_Gyro: J8.9, U6.28 (PB2)
/SPI_CS_Magnet: J8.10, U6.29 (PB10)
/SPI_MISO: J8.6, J8.7, U6.35 (PB14), U7.9 (SPI_MISO)
/SPI_MOSI: J8.4, U6.36 (PB15), U7.8 (SPI_MOSI)
/SPI_SCK: J8.3, U6.34 (PB13), U7.7 (SPI_SCK)
/SWCLK: J2.9, U6.49 (PA14)
/SWDIO: J2.7, U6.46 (PA13)
/SWO: J2.13, U6.55 (PB3)
/TEMP_OUT: J11.20, R81.1
/TMC_CLK: U7.51 (CLK), U20.4
/VCAP_1: C24.1, U6.31 (VCAP_1)
/VCAP_2: C25.1, U6.47 (VCAP_2)
/accelerator_pedal: R90.1, U6.11 (PC3)
/braking_pedal: J15.2, U6.10 (PC2)
/reset: J2.15, R18.2, U6.7 (NRST)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C33.2, C34.2, C35.2, C37.2, C38.2, C39.2, C41.2, C43.2, C44.2, C45.2, C46.2, C47.2, C49.2, C50.2, C51.2, C53.2, C54.2, C55.2, C56.2, C57.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C72.2, C73.2, C76.2, C78.2, C79.2, C80.2, C81.2, J2.4, J2.6, J2.8, J2.10, J2.12, J4.6, J4.8, J4.10, J5.6 (VSS), J5.11 (SHIELD), J8.2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
GNDPWR: C32.2, C40.2, C48.2, C58.2, J3.1, J3.2, R15.2, R33.2, R49.2, R67.2, U2.3 (IN-), U2.4 (GND1), U4.3 (IN-), U4.4 (GND1), U9.3 (IN-), U9.4 (GND1), U15.3 (IN-), U15.4 (GND1)
unnamed: C17.1, C33.1, R1.1, R16.2, R17.1, U3.4 (-)
unnamed: C32.1, R13.1, U2.2 (IN)
unnamed: C36.1, C41.1, R20.1, R34.2, R35.1, U5.4 (-)
unnamed: C40.1, R21.2, R33.1, U4.2 (IN)
unnamed: C42.1, C49.1, R36.1, R50.2, R51.1, U10.4 (-)
unnamed: C48.1, R37.2, R49.1, U9.2 (IN)
unnamed: C52.1, C61.1, R53.1, R68.2, R73.1, U16.4 (-)
unnamed: C56.1, R63.2, R64.1, U12.3 (+)
unnamed: C58.1, R54.2, R67.1, U15.2 (IN)
unnamed: C62.1, R74.2, R75.1, U17.3 (+)
unnamed: C66.1, R81.2, R86.1, U21.3 (+)
unnamed: C78.1, R91.1, TH1.2, U26.3 (+)
unnamed: D1.1 (K), R19.1
unnamed: J13.2, R90.2, R92.1
unnamed: J15.1, R89.2
unnamed: L1.2, U23.2 (+Vin)
unnamed: R2.2, R3.2
unnamed: R3.1, R4.1
unnamed: R4.2, R5.2
unnamed: R5.1, R6.1
unnamed: R6.2, R7.2
unnamed: R7.1, R8.1
unnamed: R8.2, R9.2
unnamed: R9.1, R10.1
unnamed: R10.2, R11.2
unnamed: R2.1, R13.2, R15.1
unnamed: R14.1, U3.3 (+)
unnamed: R14.2, U2.7 (OUT+)
unnamed: R16.1, U2.6 (OUT-)
unnamed: R21.1, R22.1
unnamed: R22.2, R23.2
unnamed: R23.1, R24.1
unnamed: R24.2, R25.2
unnamed: R25.1, R26.1
unnamed: R26.2, R27.2
unnamed: R27.1, R28.1
unnamed: R28.2, R29.2
unnamed: R30.2, U7.50 (nRST)
unnamed: R32.1, U5.3 (+)
unnamed: R32.2, U4.7 (OUT+)
unnamed: R34.1, U4.6 (OUT-)
unnamed: R37.1, R38.1
unnamed: R38.2, R39.2
unnamed: R39.1, R40.1
unnamed: R40.2, R41.2
unnamed: R41.1, R42.1
unnamed: R42.2, R43.2
unnamed: R43.1, R44.1
unnamed: R44.2, R45.2
unnamed: R46.2, U8.3 (VIOUT)
unnamed: R47.1, U10.3 (+)
unnamed: R47.2, U9.7 (OUT+)
unnamed: R50.1, U9.6 (OUT-)
unnamed: R52.2, U11.3 (VIOUT)
unnamed: R54.1, R55.1
unnamed: R55.2, R56.2
unnamed: R56.1, R57.1
unnamed: R57.2, R58.2
unnamed: R58.1, R59.1
unnamed: R59.2, R60.2
unnamed: R60.1, R61.1
unnamed: R61.2, R62.2
unnamed: R65.1, U16.3 (+)
unnamed: R65.2, U15.7 (OUT+)
unnamed: R66.2, U14.3 (VIOUT)
unnamed: R68.1, U15.6 (OUT-)
unnamed: R80.2, U19.3 (VIOUT)
unnamed: R87.1, R88.2, U22.4 (-)
unnamed: R93.1, R94.2, U27.4 (-)
unnamed: U21.1, U21.4 (-), U22.3 (+)
unnamed: U26.1, U26.4 (-), U27.3 (+)

Notes on the sheet:
DC/DC Converters
Motor
IGBTs
POWER
Field-Oriented controller
MOTOR
Cortex-M4 Microcontroller
MCU
DC Bus & Motor Phases
CURRENT SENSORS
Motor & IGBTs
TEMPERATURE SENSORS
CAN & SDCard
DATA LOGGER
VOLTAGE SENSORS
DC Bus
Accelerator & Brake
PEDALS
ADC

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
Board: 2 copper layers, 105.3 x 169.1 mm, 232 parts (112 on the bottom side), 158 nets.

## Code that names these connections

File salvacao/salvacao.ioc (part):

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Mcu.Name=STM32F405RGTx
Mcu.Package=LQFP64
Mcu.UserName=STM32F405RGTx
PA0-WKUP.GPIOParameters=GPIO_Label
PA0-WKUP.GPIO_Label=enc_a
PA0-WKUP.Signal=S_TIM2_CH1_ETR
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=enc_b
PA1.Signal=S_TIM2_CH2
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=curr_w
PA2.Signal=ADCx_IN2
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=DC_Bus_Voltage
PA3.Signal=ADCx_IN3
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=Accel_CS
PA4.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=DC_Current
PA6.Signal=ADCx_IN6
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=motor_voltage_u
PA7.Signal=ADCx_IN7
PA8.Mode=Clock-out-1
PA8.Signal=RCC_MCO_1
PB0.Signal=ADCx_IN8
PB1.Signal=ADCx_IN9
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=Magnet_CS
PB10.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=SPI_CS_FOC
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=Gyro_CS
PB2.Signal=GPIO_Output
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=curr_u
PC0.Signal=ADCx_IN10
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=curr_v
PC1.Signal=ADCx_IN11
PC10.GPIOParameters=GPIO_PuPd
PC10.GPIO_PuPd=GPIO_NOPULL
PC10.Mode=SD_4_bits_Wide_bus
PC10.Signal=SDIO_D2
PC11.GPIOParameters=GPIO_PuPd
PC11.GPIO_PuPd=GPIO_NOPULL
PC11.Mode=SD_4_bits_Wide_bus
PC11.Signal=SDIO_D3
PC12.Mode=SD_4_bits_Wide_bus
PC12.Signal=SDIO_CK
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=brk_pedal
PC2.Signal=ADCx_IN12
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=acc_pedal
PC3.Signal=ADCx_IN13
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=motor_voltage_v
PC4.Signal=ADCx_IN14
PC5.GPIOParameters=GPIO_Label
PC5.GPIO_Label=motor_voltage_w
PC5.Signal=ADCx_IN15
PC7.GPIOParameters=GPIO_PuPd,GPIO_Label
PC7.GPIO_Label=SD_Det
PC7.GPIO_PuPd=GPIO_NOPULL
PC7.Signal=GPIO_Input
PC8.GPIOParameters=GPIO_PuPd
PC8.GPIO_PuPd=GPIO_PULLUP
PC8.Mode=SD_4_bits_Wide_bus
PC8.Signal=SDIO_D0
PC9.GPIOParameters=GPIO_PuPd
PC9.GPIO_PuPd=GPIO_NOPULL
PC9.Mode=SD_4_bits_Wide_bus
PC9.Signal=SDIO_D1
PD2.GPIOParameters=GPIO_PuPd
PD2.GPIO_PuPd=GPIO_PULLUP
PD2.Mode=SD_4_bits_Wide_bus
PD2.Signal=SDIO_CMD
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File firmware/fiat.ioc (part):

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Mcu.Name=STM32F405RGTx
Mcu.Package=LQFP64
Mcu.UserName=STM32F405RGTx
PA0-WKUP.GPIOParameters=GPIO_PuPd,GPIO_Label
PA0-WKUP.GPIO_Label=encoder_va
PA0-WKUP.GPIO_PuPd=GPIO_PULLUP
PA0-WKUP.Signal=S_TIM2_CH1_ETR
PA1.GPIOParameters=GPIO_PuPd,GPIO_Label
PA1.GPIO_Label=encoder_vb
PA1.GPIO_PuPd=GPIO_PULLUP
PA1.Signal=S_TIM2_CH2
PA11.Mode=Master
PA11.Signal=CAN1_RX
PA12.Mode=Master
PA12.Signal=CAN1_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=current_ph3
PA2.Signal=ADCx_IN2
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=DC_bus_voltage
PA3.Signal=ADCx_IN3
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=Accel_CS
PA4.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=DC_bus_current
PA6.Signal=ADCx_IN6
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=voltage_ph1
PA7.Signal=ADCx_IN7
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=SW_25MHz_output
PA8.Mode=Clock-out-1
PA8.Signal=RCC_MCO_1
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=Motor_temp
PB0.Signal=ADCx_IN8
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=Inverter_temp
PB1.Signal=ADCx_IN9
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=Magnet_CS
PB10.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=FOC_IC_CS
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=Gyro_CS
PB2.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=CAN_STBY
PB5.Signal=GPIO_Output
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=current_ph1
PC0.Signal=ADCx_IN10
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=current_ph2
PC1.Signal=ADCx_IN11
PC10.Mode=SD_4_bits_Wide_bus
PC10.Signal=SDIO_D2
PC11.Mode=SD_4_bits_Wide_bus
PC11.Signal=SDIO_D3
PC12.Mode=SD_4_bits_Wide_bus
PC12.Signal=SDIO_CK
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=braking_pedal
PC2.Signal=ADCx_IN12
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=accelerator_pedal
PC3.Signal=ADCx_IN13
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=voltage_ph2
PC4.Signal=ADCx_IN14
PC5.GPIOParameters=GPIO_Label
PC5.GPIO_Label=voltage_ph3
PC5.Signal=ADCx_IN15
PC7.GPIOParameters=GPIO_Label
PC7.GPIO_Label=SDIO_DET
PC7.Signal=GPIO_Input
PC8.Mode=SD_4_bits_Wide_bus
PC8.Signal=SDIO_D0
PC9.Mode=SD_4_bits_Wide_bus
PC9.Signal=SDIO_D1
PD2.Mode=SD_4_bits_Wide_bus
PD2.Signal=SDIO_CMD
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2019-10-20 Ignore Kicad temporary files
2019-10-20 KiCAD project initialization
2019-10-24 Moved pcb project
2019-10-28 pedal_signal_acquired
2019-10-28 STM32 Project Initialization
2019-10-28 Initial Pinout
2019-10-28 SDCard interfaces
2019-10-28 FATFS code
2019-10-29 sd card read/write library
2019-10-29 create_file correction
2019-10-29 cs pin
2019-10-29 Ignore compilation files
2019-10-29 Remove compilation Files
2019-10-29 Clean debug configurations
2019-10-29 Changed Sector size to 512
2019-10-29 Removed buffer when not used
2019-10-29 Unmount_card function
2019-10-29 Add printf functionality
2019-10-30 Clock Speed set to 72MHz
2019-10-30 card_capacity function fix
2019-10-30 CAN config test
2019-11-01 Tidy up thermistor schematic
2019-11-02 double_acquisition
2019-11-02 adc_start_correction
2019-11-02 delete_old_folder
2019-11-09 Current Sensors
2019-11-09 Thermistor
2019-11-09 Anotate Schematic
2019-11-10 MCU and Decoupling
2019-11-10 Initialized STM32F405RGTx
2019-11-10 KiCAD sheet decoration
2019-11-10 Pin Definitions
2019-11-11 Crystals
2019-11-11 IMU and temperature sensors connected to MCU
2019-11-11 Current Sensors connected to MCU
2019-11-11 Removed SDCard from motor controller board
2019-11-11 Added FOC controller
2019-11-11 Connected Crystals
2019-11-12 FOC controller, CAN and IGBTs
2019-11-14 IMU reading library
2019-11-16 Voltage Sensor
2019-11-17 Add files via upload
    AC Voltage sensor
2019-11-17 AC voltage sensor
2019-11-18 Added Voltage sensors
2019-11-18 Anotation
2019-11-25 clean code and conversion inside imu reading library
2019-11-28 Code cycle base skeleton
2019-12-01 DC/DC converters added
2019-12-01 ADC conversion values. Temperature and current sensors
2019-12-02 adc code
2019-12-02 adc_dma_w_conversion
2019-12-02 Formula corrected.
2019-12-02 DC/DC converters updated
2019-12-02 AC Voltage Sensor added
2019-12-02 Logic Converter
2019-12-02 FOC config library
2019-12-04 Ic FOC library update and spi mode 3
2019-12-04 Added logic conveters
2019-12-05 IC connections added
2019-12-06 Remove L and 1.8v converter
2019-12-06 Xtal circuit added
2019-12-07 adcs added
2019-12-07 micro connections added
2019-12-07 sd card connections to micro added
2019-12-08 RTMI + Pedal Sensor + DC Current Sensor
2019-12-08 SD Card and other pins
2019-12-08 Pedal Sensor + Program/Debug
2019-12-08 AC/DC
2019-12-08 pinout
2019-12-08 accelerator_pedal
2019-12-08 FOC_enable
2019-12-08 Voltage Sensors corrected
2019-12-08 Clean Schematic
2019-12-09 Encoder
2019-12-09 Pedal position conversion
2019-12-09 Resistor Series reduced
2019-12-09 Initial Work on PCB Layout
2019-12-10 New Encoder Circuit
2019-12-10 New Encoder Circuit V2.0
2019-12-12 Encoder and 1.8V Supply - Schematic v0.9.1
2019-12-16 Encoder Mode Config. Changed ADC1_IN0 and ADC1_IN1 to TIM2_CH1 and TIM2_CH2.
2019-12-16 onda 12.5khz
2019-12-16 update schematic pinout
2019-12-16 Fix libraries
2019-12-16 0.9.2 - Encoders
2019-12-16 0.10.0 - New Encoder Configuration
2019-12-17 Schematic v0.11.0
2019-12-17 Expansion port and connectors
2019-12-17 Fix TMC connections
2019-12-17 Initial work on PCB
2019-12-18 Schematic v1.0 and PCB in progress
2019-12-18 Library name corrected
2019-12-18 Add Bus voltage measurement to TMC4671
2019-12-19 PCB final size
2019-12-20 Change debug connectors, Motor W Voltage and round PCB corners
2019-12-22 In case encoder mode doesn't work
2019-12-22 projeto de teste com f103
2019-12-23 Update file
2019-12-24 Fix SPI
2019-12-24 Add FOC_reset and fix compilation errors
2019-12-24 Fix encoder
2019-12-28 encoder mode working (f103)
2019-12-28 PCB placing done, missing some connections
2019-12-28 PCB layout complete
2019-12-28 micro pinout
2019-12-28 temperature error removed
2019-12-29 Silkscreen ready
2019-12-29 Encoder added to the main project (temporary version).
2019-12-29 header file corrected
2019-12-30 PCB ordered
2019-12-30 preparing dma readings
2020-01-02 Encoder. Delay replaced. (f1)
2020-01-07 writing both encoder data and imu data on sd card
2020-01-08 Change encoder reading to 1 channel
2020-01-09 adding timestamp to sd card files
2020-01-09 adcUnitConversion updated
2020-01-09 Timestamps with ms
2020-01-10 encoder mode functions updated
2020-01-10 Resistors values reviewed
2020-01-11 Change voltage sensor resistors to match each other
2020-01-12 some corrections on f4
2020-01-12 encoderMode and adcUnitConversion libraries updated (f4)
2020-01-13 Basic Timer configured.
2020-01-13 Encoder mode without systick. Readings every 250ms.
2020-01-14 change to sdio
2020-01-15 é agora?
2020-01-16 ardeu
2020-01-16 SPI test
2020-01-21 projeto de teste f4
2020-01-25 read tmc registers
2020-01-29 SD Card 4bits mode.
2020-01-30 timestamp with milisecond resolution
2020-01-31 sdio with dma
2020-01-31 RMS values
2020-01-31 Schmitt Trigger software.
2020-01-31 Cleaning the code (commitment)
2020-02-03 Resistor values updated.
2020-02-04 Encoder Mode - salvacao
2020-02-04 TIM2 activation - salvacao
2020-02-06 Timer 7 interruption
2020-02-06 tmc connection library
2020-02-07 cheats
2020-02-07 Torque convertion
2020-02-07 explosion
2020-02-07 cheats working
2020-02-07 acelera
