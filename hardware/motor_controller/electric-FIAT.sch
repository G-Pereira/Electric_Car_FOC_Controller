File: hardware/motor_controller/electric-FIAT.sch (KiCad schematic (older format))
At the start: 64 parts, among them J1 Conn_01x10_Female, J2 Conn_02x13_Odd_Even, J3 Conn_01x02_Male, U1 TMC4671-ES, U10 OPA356xxDBV, U17 TEN40-1215, U18 SR05S1V8, U4 OPA356xxDBV, U5 OPA356xxDBV, U6 STM32F405RGTx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

Commit message: IC connections added
Parts:
- added C54, C55, C56: 100n, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added R48: 10k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
Connections:
- net labels added: +15V, CLK_25MHZ, DBGSPI_MISO, DBGSPI_MOSI, DBGSPI_SCK, DBGSPI_TRG, DBGSPI_nSCS, ENABLE_INPUTS, ENCODER_VA, ENCODER_VB, ERROR_HB1, ERROR_HB2, ERROR_HB3, PWM_UX1_H_15V, PWM_UX1_H_3V3, PWM_UX1_L_15V, PWM_UX1_L_3V3, PWM_VX2_H_15V, PWM_VX2_H_3V3, PWM_VX2_L_15V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
- wire segments 243 -> 271
- no-connect marks 12 -> 35
Other:
- moved on the sheet: U1

Commit message: Remove L and 1.8v converter
Parts:
- removed C48, C49: 470u, symbol Device:C
- removed U18: SR05S1V8, Converter_DCDC:Converter_DCDC_muRata_OKI-78SR_Vertical, symbol Converter_DCDC:OKI-78SR-3.3_1.5-W36-C
- added L1: 4.7u, symbol Device:L
Connections:
- wire segments 271 -> 268
Other:
- note removed: "12V/1.8V\n"
Changed lines of the file:
@@
 EESchema Schematic File Version 4
+LIBS:electric-FIAT-cache
 EELAYER 30 0
 EELAYER END
@@
 12V/5V\n
 $Comp
-L Converter_DCDC:OKI-78SR-3.3_1.5-W36-C U18
-U 1 1 5DFE98FD
-P 9100 2900
-F 0 "U18" H 9100 3142 50  0000 C CNN
-F 1 "SR05S1V8" H 9100 3051 50  0000 C CNN
-F 2 "Converter_DCDC:Converter_DCDC_muRata_OKI-78SR_Vertical" H 9150 2650 50  0001 L CIN
-F 3 "https://power.murata.com/data/power/oki-78sr.pdf" H 9100 2900 50  0001 C CNN
-	1    9100 2900
-	1    0    0    -1
-$EndComp
-$Comp
-L Device:C C48
-U 1 1 5DFEFE09
-P 8200 3050
-F 0 "C48" H 8315 3096 50  0000 L CNN
-F 1 "470u" H 8315 3005 50  0000 L CNN
-F 2 "" H 8238 2900 50  0001 C CNN
-F 3 "~" H 8200 3050 50  0001 C CNN
-F 4 "35V" H 8200 3050 50  0000 C CNN "Note"
-	1    8200 3050
-	1    0    0    -1
-$EndComp
-$Comp
-L Device:C C49
-U 1 1 5DFFBC34
-P 8600 3050
-F 0 "C49" H 8715 3096 50  0000 L CNN
-F 1 "470u" H 8715 3005 50  0000 L CNN
-F 2 "" H 8638 2900 50  0001 C CNN
-F 3 "~" H 8600 3050 50  0001 C CNN
-F 4 "35V" H 8600 3050 50  0000 C CNN "Note"
-	1    8600 3050
-	1    0    0    -1
-$EndComp
-$Comp
-L power:GND #PWR085
-U 1 1 5E017F17
-P 9100 3200
-F 0 "#PWR085" H 9100 2950 50  0001 C CNN
-F 1 "GND" H 9105 3027 50  0000 C CNN
-F 2 "" H 9100 3200 50  0001 C CNN
-F 3 "" H 9100 3200 50  0001 C CNN
-	1    9100 3200
-	1    0    0    -1
-$EndComp
-$Comp
-L power:+12V #PWR084
-U 1 1 5E077170
-P 8200 2900
-F 0 "#PWR084" H 8200 2750 50  0001 C CNN
-F 1 "+12V" H 8215 3073 50  0000 C CNN
-F 2 "" H 8200 2900 50  0001 C CNN
-F 3 "" H 8200 2900 50  0001 C CNN
-	1    8200 2900
-	1    0    0    -1
-$EndComp
-Connection ~ 8200 2900
-Wire Wire Line
-	8200 3200 8600 3200
-Wire Wire Line
-	8600 3200 9100 3200
-Connection ~ 8600 3200
-Connection ~ 9100 3200
-Wire Wire Line
-	8800 2900 8600 2900
-Connection ~ 8600 2900
-Text Notes 8350 2650 0    100  ~ 0
-12V/1.8V\n
-$Comp
 L Converter_DCDC:ITX1203SA PS1
 U 1 1 5E16EBC4
@@
 	9100 2100 9450 2100
 Wire Wire Line
-	10100 2600 10500 2600
-Wire Wire Line
-	8200 2900 8600 2900
+	10100 2600 10150 2600
 $Sheet
 S 9150 8150 550  200
@@
 Wire Wire Line
 	6850 3600 7000 3600
+$Comp
+L Device:L L1
+U 1 1 5DEE311C
+P 10300 2600
+F 0 "L1" V 10119 2600 50  0000 C CNN
+F 1 "4.7u" V 10210 2600 50  0000 C CNN
+F 2 "" H 10300 2600 50  0001 C CNN
+F 3 "~" H 10300 2600 50  0001 C CNN
+	1    10300 2600
+	0    1    1    0
+$EndComp
+Wire Wire Line
+	10450 2600 10500 2600
 $EndSCHEMATC

Commit message: Xtal circuit added
Parts:
- added C48, C49, C57, C58, C59, C60, C61, C62, C63: 10u, symbol Device:C
- added J?: Micro_SD_Card_Det, symbol Connector:Micro_SD_Card_Det
- added J?: RTMI, symbol Connector_Generic:Conn_02x05_Odd_Even
- added JP? (x2): Jumper, symbol Device:Jumper
- added R?: 1M, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added R?: 3k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added U?: 74LS04, symbol 74xx:74LS04
- C51: value 4.7u -> 10u
- C52: value 220p -> 2.2n
- C53: value 100u -> 10u
Connections:
- net CLK_25MHZ: now also JP?.2, JP?.2
- net GND: now also C48.2, C49.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2; no longer J2.21 (Pin_21), J2.23 (Pin_23), J2.25 (Pin_25)
- net HSE_IN: now also R?.2, U?.1
- net HSE_OUT: now also R?.2
- net at C53.1, PS1.6 (+Vout): now also C48.1, C49.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1
- new net: JP?.1, R?.1, R?.1, U?.2
Other:
- moved on the sheet: C22, C23, C51, C52, C53, L1, PS1, PS2, R1, R3, R4, TH1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

Commit message: micro connections added
Connections:
- net CAN_STBY: now also U6.51 (PC10); no longer U6.43 (PA10)
- net ENCODER_VA: now also U6.8 (PC0)
- net ENCODER_VB: now also U6.9 (PC1)
- net SPI1_CS_Gyro: now also U6.28 (PB2); no longer U6.24 (PC4)
- net SPI1_CS_Magnet: now also U6.29 (PB10); no longer U6.25 (PC5)
- net SPI2_MISO: now also J1.6 (Pin_6), J1.7 (Pin_7)
- net SPI2_MOSI: now also J1.4 (Pin_4)
- net SPI2_NSS: now also U6.21 (PA5)
- net SPI2_SCK: now also J1.3 (Pin_3)
- net braking_pedal: now reaches U6.10 (PC2)
- net accelerator_pedal: now reaches U6.11 (PC3)
- net voltage_dc_bus: now reaches U6.17 (PA3)
- net Square_Wave_25MHz: now reaches U6.41 (PA8)
- net USART_TX: now reaches U6.42 (PA9)
- removed net SPI1_MISO: J1.6 (Pin_6), J1.7 (Pin_7), U6.22 (PA6)
- net SPI1_MOSI renamed voltage_ph1
- net voltage_ph1: no longer J1.4 (Pin_4)
- removed net SPI1_SCK: J1.3 (Pin_3), U6.21 (PA5)
- new net USART_RX: U6.43 (PA10)
- new net current_dc_bus: U6.22 (PA6)
- new net voltage_ph2: U6.24 (PC4)
- new net voltage_ph3: U6.25 (PC5)
Changed lines of the file:
@@
 EESchema Schematic File Version 4
-LIBS:electric-FIAT-cache
 EELAYER 30 0
 EELAYER END
@@
 $EndComp
 Text Label 13200 10350 2    50   ~ 0
-SPI1_SCK
+SPI2_SCK
 Text Label 13200 10450 2    50   ~ 0
-SPI1_MOSI
+SPI2_MOSI
 Text Label 13150 10700 2    50   ~ 0
-SPI1_MISO
+SPI2_MISO
 Wire Wire Line
 	13150 10700 13200 10700
@@
 Wire Wire Line
 	1100 3700 1200 3700
-Text Label 2600 4200 0    50   ~ 0
-SPI1_SCK
-Text Label 2600 4400 0    50   ~ 0
-SPI1_MOSI
 $Comp
 L Device:C C20
@@
 	2850 3200 2500 3200
 Connection ~ 2500 3200
-Text Label 2600 4300 0    50   ~ 0
-SPI1_MISO
-Text Label 2600 4100 0    50   ~ 0
-SPI1_CS_Accel
-Text Label 1200 5800 2    50   ~ 0
-SPI1_CS_Gyro
-Text Label 1200 5900 2    50   ~ 0
+Text Label 2600 6400 0    50   ~ 0
 SPI1_CS_Magnet
 Text Label 2600 5400 0    50   ~ 0
@@
 CAN_STBY
 Text Label 2600 4700 0    50   ~ 0
-CAN_STBY
+USART_RX
 $Comp
 L fiat:TMC4671-ES U1
@@
 Text Label 4400 4600 2    50   ~ 0
 FOC_Status
-$Comp
-L MCU_ST_STM32F4:STM32F405RGTx U6
-U 1 1 5DC72DB0
-P 1900 5300
-F 0 "U6" H 2200 3400 50  0000 C CNN
-F 1 "STM32F405RGTx" H 2450 3500 50  0000 C CNN
-F 2 "Package_QFP:LQFP-64_10x10mm_P0.5mm" H 1300 3600 50  0001 R CNN
-F 3 "http://www.st.com/st-web-ui/static/active/en/resource/technical/document/datasheet/DM00037051.pdf" H 1900 5300 50  0001 C CNN
-	1    1900 5300
-	1    0    0    -1
-$EndComp
 Wire Wire Line
 	1350 2350 1350 2250
@@
 Wire Wire Line
 	2500 2450 2500 2550
+Text Label 2600 4500 0    50   ~ 0
+Square_Wave_25MHz
+Text Label 2600 4600 0    50   ~ 0
+USART_TX
+Text Label 1200 5400 2    50   ~ 0
+ENCODER_VA
+Text Label 1200 5500 2    50   ~ 0
+ENCODER_VB
+Text Label 1200 5600 2    50   ~ 0
+braking_pedal
+Text Label 1200 5700 2    50   ~ 0
+accelerator_pedal
+Text Label 2600 5600 0    50   ~ 0
+SPI1_CS_Gyro
+Text Label 2600 4000 0    50   ~ 0
+voltage_dc_bus
+$Comp
+L MCU_ST_STM32F4:STM32F405RGTx U6
+U 1 1 5DC72DB0
+P 1900 5300
+F 0 "U6" H 2200 3400 50  0000 C CNN
+F 1 "STM32F405RGTx" H 2450 3500 50  0000 C CNN
+F 2 "Package_QFP:LQFP-64_10x10mm_P0.5mm" H 1300 3600 50  0001 R CNN
+F 3 "http://www.st.com/st-web-ui/static/active/en/resource/technical/document/datasheet/DM00037051.pdf" H 1900 5300 50  0001 C CNN
+	1    1900 5300
+	1    0    0    -1
+$EndComp
+Text Label 2600 4100 0    50   ~ 0
+SPI1_CS_Accel
+Text Label 2600 4200 0    50   ~ 0
+SPI2_NSS
+Text Label 2600 4300 0    50   ~ 0
+current_dc_bus
+Text Label 15050 6400 0    50   ~ 0
+voltage_ph1
+Text Label 15050 6800 0    50   ~ 0
+voltage_ph2
+Text Label 15050 7200 0    50   ~ 0
+voltage_ph3
+Text Label 2600 4400 0    50   ~ 0
+voltage_ph1
+Text Label 1200 5800 2    50   ~ 0
+voltage_ph2
+Text Label 1200 5900 2    50   ~ 0
+voltage_ph3
+Text Label 1200 6400 2    50   ~ 0
+CAN_STBY
 $EndSCHEMATC

Commit message: sd card connections to micro added
Connections:
- net CAN_STBY: now also U6.58 (PB6); no longer U6.51 (PC10)
- net FOC_Status: now also U6.57 (PB5); no longer U6.37 (PC6)
- net voltage_dc_bus: now also C24.2, R8.2, U10.1
- net SD_DAT0: now reaches U6.39 (PC8)
- net SD_DAT0: now also J?.7 (DAT0)
- net SD_DAT1: now reaches U6.40 (PC9)
- net SD_DAT1: now also J?.8 (DAT1)
- net SD_DAT3: now reaches U6.52 (PC11)
- net SD_DAT3: now also J?.2 (DAT3/CD)
- net SD_CLK: now reaches U6.53 (PC12)
- net SD_CLK: now also J?.5 (CLK)
- net SD_CMD: now reaches U6.54 (PD2)
- net SD_CMD: now also J?.3 (CMD)
- net SD_DAT2: now reaches J?.1 (DAT2)
- net SD_DAT2: now also U6.51 (PC10)
Changed lines of the file:
@@
 Text Label 2600 6600 0    50   ~ 0
 SPI2_NSS
-Text Label 1200 6000 2    50   ~ 0
+Text Label 2600 5900 0    50   ~ 0
 FOC_Status
 $Comp
@@
 Text Label 1200 5900 2    50   ~ 0
 voltage_ph3
+Text Label 2600 6000 0    50   ~ 0
+CAN_STBY
+Text Label 15500 4700 0    50   ~ 0
+voltage_dc_bus
+Text Label 4900 9200 2    50   ~ 0
+SD_DAT3
+Text Label 4900 9100 2    50   ~ 0
+SD_DAT2
+Text Label 4900 9300 2    50   ~ 0
+SD_CMD
+Text Label 4900 9500 2    50   ~ 0
+SD_CLK
+Text Label 4900 9700 2    50   ~ 0
+SD_DAT0
+Text Label 4900 9800 2    50   ~ 0
+SD_DAT1
 Text Label 1200 6400 2    50   ~ 0
-CAN_STBY
+SD_DAT2
+Text Label 1200 6500 2    50   ~ 0
+SD_DAT3
+Text Label 1200 5200 2    50   ~ 0
+SD_CMD
+Text Label 1200 6600 2    50   ~ 0
+SD_CLK
+Text Label 1200 6200 2    50   ~ 0
+SD_DAT0
+Text Label 1200 6300 2    50   ~ 0
+SD_DAT1
 $EndSCHEMATC

Commit message: RTMI + Pedal Sensor + DC Current Sensor
Parts:
- added RV?: Pedal Sensor, symbol Device:R_POT
Connections:
- net +3V3: now also J?.1 (Pin_1), RV?.1
- net DBGSPI_MISO: now also J?.9 (Pin_9)
- net DBGSPI_MOSI: now also J?.7 (Pin_7)
- net DBGSPI_SCK: now also J?.5 (Pin_5)
- net DBGSPI_nSCS: now also J?.3 (Pin_3)
- net GND: now also J?.10 (Pin_10), J?.6 (Pin_6), J?.8 (Pin_8), RV?.3
- net braking_pedal: now also RV?.2
Other:
- note added: "DC-Link Current Sensor"
- moved on the sheet: J?
Changed lines of the file:
@@
 EESchema Schematic File Version 4
+LIBS:electric-FIAT-cache
 EELAYER 30 0
 EELAYER END
 $Descr A3 16535 11693
 encoding utf-8
-Sheet 1 13
+Sheet 1 14
 Title "Motor Controller"
 Date "2019-11-18"
@@
 L Connector_Generic:Conn_02x05_Odd_Even J?
 U 1 1 5E3A6BB6
-P 8500 9600
-F 0 "J?" H 8550 10017 50  0000 C CNN
-F 1 "RTMI" H 8550 9926 50  0000 C CNN
-F 2 "" H 8500 9600 50  0001 C CNN
-F 3 "~" H 8500 9600 50  0001 C CNN
-	1    8500 9600
+P 3100 10400
+F 0 "J?" H 3150 10817 50  0000 C CNN
+F 1 "RTMI" H 3150 10726 50  0000 C CNN
+F 2 "" H 3100 10400 50  0001 C CNN
+F 3 "~" H 3100 10400 50  0001 C CNN
+	1    3100 10400
 	1    0    0    -1
 $EndComp
@@
 Text Label 1200 6300 2    50   ~ 0
 SD_DAT1
+$Comp
+L Device:R_POT RV?
+U 1 1 5DF3A930
+P 1150 10400
+F 0 "RV?" H 1080 10446 50  0000 R CNN
+F 1 "Pedal Sensor" H 1080 10355 50  0000 R CNN
+F 2 "" H 1150 10400 50  0001 C CNN
+F 3 "~" H 1150 10400 50  0001 C CNN
+	1    1150 10400
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR?
+U 1 1 5DF407CE
+P 1150 10550
+F 0 "#PWR?" H 1150 10300 50  0001 C CNN
+F 1 "GND" H 1155 10377 50  0000 C CNN
+F 2 "" H 1150 10550 50  0001 C CNN
+F 3 "" H 1150 10550 50  0001 C CNN
+	1    1150 10550
+	1    0    0    -1
+$EndComp
+$Comp
+L power:+3V3 #PWR?
+U 1 1 5DF5758D
+P 1150 10250
+F 0 "#PWR?" H 1150 10100 50  0001 C CNN
+F 1 "+3V3" H 1165 10423 50  0000 C CNN
+F 2 "" H 1150 10250 50  0001 C CNN
+F 3 "" H 1150 10250 50  0001 C CNN
+	1    1150 10250
+	1    0    0    -1
+$EndComp
+$Comp
+L power:+3V3 #PWR?
+U 1 1 5E015BAF
+P 2900 10200
+F 0 "#PWR?" H 2900 10050 50  0001 C CNN
+F 1 "+3V3" H 2915 10373 50  0000 C CNN
+F 2 "" H 2900 10200 50  0001 C CNN
+F 3 "" H 2900 10200 50  0001 C CNN
+	1    2900 10200
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR?
+U 1 1 5E042A59
+P 3400 10600
+F 0 "#PWR?" H 3400 10350 50  0001 C CNN
+F 1 "GND" H 3405 10427 50  0000 C CNN
+F 2 "" H 3400 10600 50  0001 C CNN
+F 3 "" H 3400 10600 50  0001 C CNN
+	1    3400 10600
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	3400 10400 3400 10500
+Connection ~ 3400 10600
+Connection ~ 3400 10500
+Wire Wire Line
+	3400 10500 3400 10600
+Text Notes 11050 5950 0    100  ~ 20
+DC-Link Current Sensor
+$Sheet
+S 11500 6200 800  300
+U 5E0A8F27
+F0 "sheet5E0A8F22" 50
+F1 "current_sensor.sch" 50
+F2 "IGBT_PH1" I L 11500 6300 50
+F3 "Motor_PH1" O L 11500 6400 50
+F4 "out" O R 12300 6300 50
+$EndSheet
+Text Label 12300 6300 0    50   ~ 0
+current_dc_bus
+Text Label 2900 10600 2    50   ~ 0
+DBGSPI_MISO
+Text Label 2900 10500 2    50   ~ 0
+DBGSPI_MOSI
+Text Label 2900 10400 2    50   ~ 0
+DBGSPI_SCK
+Text Label 2900 10300 2    50   ~ 0
+DBGSPI_nSCS
+Text Label 6800 4800 0    50   ~ 0
+GPIO0
+Text Label 6800 4900 0    50   ~ 0
+GPIO1
+Text Label 3500 10200 0    50   ~ 0
+GPIO0
+Text Label 3500 10300 0    50   ~ 0
+GPIO1
+Text Label 1300 10400 0    50   ~ 0
+braking_pedal
 $EndSCHEMATC

Commit message: SD Card and other pins
Parts:
- removed JP?: Jumper, symbol Device:Jumper
- added JP2: Jumper, symbol Device:Jumper
- added R18: 10k, symbol Device:R
- gave numbers to parts that had none: 7
- renumbered C7 to C1, C15 to C10, C16 to C11, C17 to C12, C18 to C13, C19 to C14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
Connections:
- net +3V3: now also J3.10 (DET_A), J3.4 (VDD)
- net CLK_25MHZ: now also JP2.2
- net ERROR_HB1: now also U8.59 (PB7)
- net ERROR_HB2: now also U8.61 (PB8)
- net ERROR_HB3: now also U8.62 (PB9)
- net GND: now also J3.6 (VSS), R18.2
- net Square_Wave_25MHz: now also JP2.1
- net SD_DET: now reaches U8.38 (PC7)
- net SD_DET: now also J3.9 (DET_B), R18.1
